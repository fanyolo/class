# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\User\MCO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c core_cm3.h
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
    ../User/MCO/: mco.c
  group DOC
    ../Doc/: readme.txt
